

#EXTRA_IMAGE_FEATURES = "debug-tweaks"
# The EXTRA_IMAGE_FEATURES variable allows extra packages to be added to the generated 
# images.

#CORE_IMAGE_EXTRA_INSTALL += "\
#              packagegroup-mc-packages \
#"



IMAGE_INSTALL += "mchello"